# Keil uVision project ST590.uvprojx, settings and files
target ST590 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L431CBTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x801FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: ST590
  AfterMake: fromelf.exe --bin --output .\ST590\ST590.bin .\ST590\ST590.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=4 v6LangP=3 wLevel=2
  c define: STM32L431xx,USE_FULL_LL_DRIVER,USE_HAL_DRIVER
  c include: ../Inc;       ../Drivers/STM32L4xx_HAL_Driver/Inc;       ../Drivers/CMSIS/Device/ST/STM32L4xx/Include;       ../Drivers/CMSIS/Include;       ..\User\usart;       ..\User\MODBUS\include;       ..\User\MODBUS\port;       ..\User\MODBUS\rtu;       ..\User\timer;       ..\User\LTC2630ISC6;       ..\User\delay;       ..\User\ADA2200;       ..\User\PGA113;       ..\User\DAC5410;       ..\User\APP;       ..\User\measure;       ..\Drivers\STM32L4xx_HAL_Driver\Inc;       ..\User\kf;       ..\User\Flash;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy
  library: MicroLIB
  memory RVCT4: ROM 0x8005000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32l431xx.s
  group Application/User
    ../Src/: main.c gpio.c adc.c iwdg.c tim.c stm32l4xx_it.c stm32l4xx_hal_msp.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_ll_rcc.c stm32l4xx_ll_usart.c stm32l4xx_hal_crc.c stm32l4xx_ll_utils.c stm32l4xx_ll_exti.c stm32l4xx_ll_gpio.c stm32l4xx_ll_adc.c stm32l4xx_ll_dma.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_ll_tim.c
  group User
    ../User/usart/: usart_user.c
    ../User/timer/: tim_user.c
    ../User/LTC2630ISC6/: LTC2630ISC6.C
    ../User/ADA2200/: ADA2200.c
    ../User/delay/: delay.c
    ../User/PGA113/: PGA113.C
    ../User/DAC5410/: DAC5410.c
    ../User/APP/: app.c
    ../User/measure/: measure.c
    ../User/kf/: kf.c
    ../User/Flash/: flash.c
  group Modbus
    ../User/MODBUS/functions/: mb.c mbfunccoils.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../User/MODBUS/port/: embreg.c portevent.c portserial.c porttimer.c
    ../User/MODBUS/rtu/: mbcrc.c mbrtu.c
software components: CMSIS:CORE 5.2.0
